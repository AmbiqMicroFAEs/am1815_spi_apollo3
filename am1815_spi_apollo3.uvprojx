# Keil uVision project am1815_spi_apollo3.uvprojx, settings and files
target am1815_spi_apollo3 (6180000::V6.18::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: am1815_spi_apollo3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA keil
  c include: .\startup;..\SDK\mcu\apollo3;..\SDK\mcu\apollo3\hal;..\SDK\mcu\apollo3\regs;..\SDK\CMSIS\AmbiqMicro\Include;..\SDK\CMSIS\AmbiqMicro\Source;..\SDK\CMSIS\ARM\Include;..\SDK\CMSIS\ARM\Lib\ARM;..\SDK\devices;..\SDK\utils;..\SDK\boards\apollo3_evb\bsp;.\src
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  link misc: ../SDK/mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group source
    ./src/: main.c uart_debug.c uart_debug.h iom_dma.c iom_dma.h amx8x5_device.c amx8x5_device.h iom_spi.c iom_spi.h
  group startup
    ./startup/: startup_keil.s
  group utils
    ../SDK/utils/: am_util_delay.c am_util_delay.h am_util_stdio.c am_util_stdio.h am_util_string.c am_util_string.h am_util_time.c am_util_time.h am_util_debug.c am_util_debug.h
  group hal
    ../SDK/mcu/apollo3/hal/: am_hal_cachectrl.c am_hal_cachectrl.h am_hal_clkgen.c am_hal_clkgen.h am_hal_ctimer.c am_hal_ctimer.h am_hal_debug.c am_hal_debug.h am_hal_gpio.c am_hal_gpio.h am_hal_interrupt.c am_hal_interrupt.h am_hal_iom.c am_hal_iom.h am_hal_ios.c am_hal_ios.h am_hal_itm.c am_hal_itm.h am_hal_mcuctrl.c am_hal_mcuctrl.h am_hal_mspi.c am_hal_mspi.h am_hal_pin.h am_hal_pwrctrl.c am_hal_pwrctrl.h am_hal_pwrctrl_internal.h am_hal_reset.c am_hal_reset.h am_hal_rtc.c am_hal_rtc.h am_hal_scard.c am_hal_scard.h am_hal_secure_ota.c am_hal_secure_ota.h am_hal_security.c am_hal_security.h am_hal_status.h am_hal_stimer.c am_hal_stimer.h am_hal_sysctrl.c am_hal_sysctrl.h am_hal_systick.c am_hal_systick.h am_hal_tpiu.c am_hal_tpiu.h am_hal_uart.c am_hal_uart.h am_hal_wdt.c am_hal_wdt.h am_hal_flash.c am_hal_flash.h am_hal_adc.c am_hal_adc.h am_hal_ble.c am_hal_ble.h am_hal_ble_patch.c am_hal_ble_patch.h am_hal_ble_patch_b0.c am_hal_ble_patch_b0.h am_hal_burst.c am_hal_burst.h am_hal_cmdq.c am_hal_cmdq.h am_hal_entropy.c am_hal_entropy.h am_hal_pdm.c am_hal_pdm.h am_hal_queue.c am_hal_queue.h
